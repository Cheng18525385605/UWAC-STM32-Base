# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\adc;.\APP\dma;.\APP\sound_wav;.\APP\sd;.\Fatfs\src;.\Fatfs\fatfs_app;.\APP\tftlcd;.\Malloc;.\APP\flash;.\APP\spi;.\Fatfs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c usart.c parse_cmd.c uart_cmd_process.c
  group APP
    ./APP/led/: led.c
    ./APP/pwm/: pwm.c
    ./APP/time/: time.c
    ./APP/adc/: adc.c
    ./APP/dma/: dma.c
    ./APP/sound_wav/: wav.c
    ./APP/sd/: sdio_sdcard.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/flash/: flash.c
    ./APP/spi/: spi.c
  group Fatfs
    ./Fatfs/fatfs_app/: fatfs_app.c
    ./Fatfs/src/: ff.c diskio.c
    ./Fatfs/src/option/: cc936.c
  group my_malloc
    ./Malloc/: malloc.c
